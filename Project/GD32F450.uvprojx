# Keil uVision project GD32F450.uvprojx, settings and files
target GD32F450 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F450 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F450,USE_USB_FS,__CC_ARM,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware\led;..\Hardware\usart;..\Hardware\key;..\Hardware\timer;..\Hardware\dma;..\Hardware\spi;..\Hardware\sdio;..\FatFs\FatFs\src;..\FatFs\FatFs\src\option;..\FatFs\FatFs\src\drivers;..\Hardware\lcd;..\Hardware\adc;..\DSP_LIB;..\DSP_LIB\Include;..\Hardware\core;..\Hardware\fft;..\Hardware\sdram;..\Hardware\dac
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: systick.c gd32f4xx_it.c main.c
  group Hardware
    ../Hardware/led/: bsp_led.c
    ../Hardware/usart/: bsp_usart.c
    ../Hardware/key/: bsp_key.c
    ../Hardware/timer/: bsp_basic_timer.c
    ../Hardware/dma/: bsp_dma.c
    ../Hardware/spi/: bsp_spi.c ws_drive_w25qxx.c
    ../Hardware/sdio/: sdcard.c bsp_sdcard.c
    ../Hardware/lcd/: bsp_lcd.c
    ../Hardware/core/: wb_core.c
    ../Hardware/fft/: fft.c
    ../Hardware/adc/: bsp_adc.c
    ../Hardware/sdram/: exmc_sdram.c
    ../Hardware/dac/: bsp_dac.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_sdio.c gd32f4xx_exmc.c gd32f4xx_pmu.c gd32f4xx_tli.c gd32f4xx_ctc.c gd32f4xx_adc.c gd32f4xx_dac.c gd32f4xx_spi.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group FatFs
    ../FatFs/FatFs/src/: diskio.c ff.c ff_gen_drv.c fatfs.c ffconf.h
    ../FatFs/FatFs/src/option/: syscall.c ccsbcs.c
    ../FatFs/FatFs/src/drivers/: sd_diskio.c
  group DSP
    ../DSP_LIB/: arm_cortexM4lf_math.lib
    ../DSP_LIB/Include/: core_cm4.h arm_math.h
